# Keil uVision project final robot.uvprojx, settings and files
target final robot (6210000::V6.21::ARMCLANG)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: can
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_PRESENT=1U
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../application;../bsp/boards;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../components;../components/algorithm;../components/controller;../components/device;../components/controller/control_alg;../components/controller/math_util;../components/controller/control_util;../components/controller/gimbal_control;../components/controller/temp_pid;../components/controller/br_chassis_control;../components/controller/shoot_rev_control;../components/controller/std_chassis_control;../components/controller/referee_alg;../components/controller/sentry_chassis_control;../components/controller/robot_config;../components/controller/kalman_filter;../components/support;../Drivers/CMSIS/DSP_Lib/Source/BasicMathFunctions;../Drivers/CMSIS/DSP_Lib/Source/CommonTables;../Drivers/CMSIS/DSP_Lib/Source/ComplexMathFunctions;../Drivers/CMSIS/DSP_Lib/Source/ControllerFunctions;../Drivers/CMSIS/DSP_Lib/Source/FastMathFunctions;../Drivers/CMSIS/DSP_Lib/Source/FilteringFunctions;../Drivers/CMSIS/DSP_Lib/Source/MatrixFunctions;../Drivers/CMSIS/DSP_Lib/Source/StatisticsFunctions;../Drivers/CMSIS/DSP_Lib/Source/SupportFunctions;../Drivers/CMSIS/DSP_Lib/Source/TransformFunctions
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/CMSIS/DSP_Lib/Source/MatrixFunctions
    ../Drivers/CMSIS/DSP_Lib/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
  group boards
    ../bsp/boards/: bsp_can.c bsp_delay.c bsp_imu_pwm.c bsp_led.c bsp_spi.c bsp_rc.c bsp_usart.c
  group applications
    ../application/: CAN_receive.c INS_task.c chassis_task.c remote_control.c gimbal_task.c shooting_task.c referee.c referee_usart_task.c AI_receive.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group algorithm
    ../components/algorithm/: user_lib.c FusionAhrs.c FusionCompass.c FusionOffset.c
  group controller
    ../components/controller/robot_config/: robot_config.c
    ../components/controller/std_chassis_control/: std_chassis_control.c
    ../components/controller/br_chassis_control/: br_chassis_control.c
    ../components/controller/gimbal_control/: gimbal_control.c
    ../components/controller/shoot_rev_control/: shoot_rev_control.c
    ../components/controller/control_alg/: control_alg.c
    ../components/controller/control_util/: control_util.c
    ../components/controller/kalman_filter/: kalman_filter.c
    ../components/controller/math_util/: math_util.c
    ../components/controller/referee_alg/: referee_alg.c
    ../components/controller/temp_pid/: pid.c
  group devices
    ../components/device/: BMI088driver.c BMI088Middleware.c ist8310driver.c ist8310driver_middleware.c
  group support
    ../components/support/: CRC8_CRC16.c fifo.c
software components: CMSIS:CORE 5.6.0
